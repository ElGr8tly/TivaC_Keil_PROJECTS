# Keil uVision project wdt.uvprojx, settings and files
target WDT_TEST (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GPIOv1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group WDT
    ./Code/: wdt_test.c wdt_driver.c common.h wdt.h
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.1
