# Keil uVision project RGB_Brightness_V1.uvprojx, settings and files
target GPIOv3 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RGB_Brightness +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APP
    ../../APP/: app3_rgb_brightness.c app3_rgb_brightness.h
  group HAL
    ../../HAL/BUTTON/: button_interface.h button_program.c
    ../../HAL/RGB_LED/: rgb_led_config.c rgb_led_config.h rgb_led_interface.h rgb_led_private.h rgb_led_program.c
    ../../HAL/LED/: leds_interface.h leds_program.c
    ../../HAL/PWM/: pwm_interface.h pwm_private.h pwm_program.c
  group MCAL
    ../../MCAL/GPIO/: gpio_config.h gpio_interface.h gpio_private.h gpio_program.c
    ../../MCAL/SYSTICK/: systick_config.c systick_config.h systick_interface.h systick_private.h systick_program.c
    ../../MCAL/GPT/: gpt_interface.h gpt_private.h gpt_program.c
  group LIB
    ../../LIB/: bit_math.h error_check.c error_check.h std_types.h
    ../../APP/: app3_rgb_brightness.c app3_rgb_brightness.h
  group MAIN
    ../../MAIN/: main.c
  group SERVICES
    ../../SERVICES/TMU/: tmu_interface.h tmu_private.h tmu_program.c
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.1
